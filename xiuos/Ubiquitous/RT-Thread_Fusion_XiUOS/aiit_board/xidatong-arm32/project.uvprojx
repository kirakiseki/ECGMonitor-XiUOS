# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: SKIP_SYSCLK_INIT, CPU_MIMXRT1052CVL5B, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: applications;..\..\..\..\APP_Framework\lib\cJSON;..\..\..\..\APP_Framework\Framework\connection;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m7;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;board;board\MCUX_Config;board\ports;board\usb;..\..\rt-thread\bsp\imxrt\libraries\drivers;..\..\rt-thread\bsp\imxrt\libraries\drivers\config;..\..\rt-thread\components\dfs\include;..\..\rt-thread\components\dfs\filesystems\devfs;..\..\rt-thread\components\dfs\filesystems\elmfat;..\..\rt-thread\components\finsh;.;..\..\rt-thread\include;..\..\rt-thread\components\libc\compilers\armlibc;..\..\rt-thread\components\libc\compilers\common;..\..\rt-thread\components\libc\compilers\common\nogcc;..\..\rt-thread\components\libc\posix\pthreads;..\..\rt-thread\bsp\imxrt\libraries\MIMXRT1050\CMSIS\Include;..\..\rt-thread\bsp\imxrt\libraries\MIMXRT1050\MIMXRT1052;..\..\rt-thread\bsp\imxrt\libraries\MIMXRT1050\MIMXRT1052\drivers;..\..\..\..\APP_Framework\Applications\general_functions\list;..\..\rt-thread\components\net\lwip-2.1.2\src;..\..\rt-thread\components\net\lwip-2.1.2\src\include;..\..\rt-thread\components\net\lwip-2.1.2\src\arch\include;..\..\rt-thread\components\net\lwip-2.1.2\src\include\netif;..\..\..\..\APP_Framework\Framework\knowing\ota;..\..\rt-thread\components\net\netdev\include;..\..\rt-thread\components\net\sal_socket\include;..\..\rt-thread\components\net\sal_socket\include\socket;..\..\rt-thread\components\net\sal_socket\impl;..\..\rt-thread\components\net\sal_socket\include\dfs_net;..\..\rt-thread\components\net\sal_socket\include\socket\sys_socket;..\..\..\..\APP_Framework\Framework\sensor;..\..\..\..\APP_Framework\Applications;..\..\..\..\APP_Framework\Framework\sensor\altitude\bmp180;..\..\..\..\APP_Framework\Framework\sensor\ch4\as830;..\..\..\..\APP_Framework\Framework\sensor\co2\g8s;..\..\..\..\APP_Framework\Framework\sensor\co2\zg09;..\..\..\..\APP_Framework\Framework\sensor\hcho\tb600b_wq_hcho1os;..\..\..\..\APP_Framework\Framework\sensor\humidity\hs300x_humi;..\..\..\..\APP_Framework\Framework\sensor\temperature\hs300x_temp;..\..\..\..\APP_Framework\Framework\sensor\voice\d124;..\..\..\..\APP_Framework\Framework\sensor\winddirection\qs-fx;..\..\..\..\APP_Framework\Framework\sensor\windspeed\qs-fs;..\..\..\..\APP_Framework\Framework\transform_layer\rtthread;..\..\rt-thread\examples\utest\testcases\kernel;..\..\..\..\APP_Framework\Applications\webnet\WebNet_XiUOS\inc;xip
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)
  group Applications
    applications/: main.c
  group cjson
    ../../../../APP_Framework/lib/cJSON/: cJSON.c
  group CPU
    ../../rt-thread/libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/cputime/: cputime.c
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/phy/: phy.c
    ../../rt-thread/components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/src/: ringblk_buf.c completion.c waitqueue.c workqueue.c ringbuffer.c dataqueue.c pipe.c
  group Drivers
    board/ports/: sdcard_port.c LAN8720A.c
    board/MCUX_Config/: pin_mux.c clock_config.c
    board/: board.c
    ../../rt-thread/bsp/imxrt/libraries/drivers/: drv_gpio.c drv_uart.c drv_sdram.c drv_mdio.c drv_eth.c drv_sdio.c
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../../rt-thread/components/dfs/filesystems/elmfat/: ff.c dfs_elm.c ffunicode.c
  group Finsh
    ../../rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../rt-thread/src/: scheduler.c clock.c ipc.c memheap.c device.c kservice.c mempool.c timer.c object.c thread.c components.c irq.c idle.c
  group libc
    ../../rt-thread/components/libc/compilers/armlibc/: libc.c syscalls.c mem_std.c stdio.c
    ../../rt-thread/components/libc/compilers/common/: stdlib.c unistd.c delay.c time.c
    ../../rt-thread/components/libc/posix/pthreads/: pthread_mutex.c pthread_barrier.c pthread_rwlock.c mqueue.c pthread_tls.c pthread_spin.c semaphore.c pthread_cond.c sched.c pthread.c pthread_attr.c
  group Libraries
    ../../rt-thread/bsp/imxrt/libraries/MIMXRT1050/MIMXRT1052/: system_MIMXRT1052.c
    ../../rt-thread/bsp/imxrt/libraries/MIMXRT1050/MIMXRT1052/drivers/: fsl_gpio.c fsl_lpuart.c fsl_usdhc.c fsl_semc.c fsl_clock.c fsl_cache.c fsl_common.c fsl_enet.c
    ../../rt-thread/bsp/imxrt/libraries/MIMXRT1050/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group list
    ../../../../APP_Framework/Applications/general_functions/list/: double_list.c single_list.c
  group lwIP
    ../../rt-thread/components/net/lwip-2.1.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c if_api.c
    ../../rt-thread/components/net/lwip-2.1.2/src/core/: ip.c netif.c sys.c altcp_alloc.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c altcp.c tcp_in.c dns.c timeouts.c udp.c altcp_tcp.c pbuf.c def.c tcp.c
    ../../rt-thread/components/net/lwip-2.1.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    ../../rt-thread/components/net/lwip-2.1.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../rt-thread/components/net/lwip-2.1.2/src/arch/: sys_arch.c
    ../../rt-thread/components/net/lwip-2.1.2/src/apps/ping/: ping.c
  group SAL
    ../../rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    ../../rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
    ../../rt-thread/components/net/sal_socket/src/: sal_socket.c
    ../../rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
  group sensor
    ../../../../APP_Framework/Applications/: framework_init.c
  group transform
    ../../../../APP_Framework/Framework/transform_layer/rtthread/: transform.c
  group WebNet
    ../../../../APP_Framework/Applications/webnet/WebNet_XiUOS/module/: wn_module_asp.c wn_module_alias.c wn_module_auth.c wn_module_ssi.c wn_module_cgi.c wn_module_index.c wn_module_upload.c wn_module_log.c
    ../../../../APP_Framework/Applications/webnet/WebNet_XiUOS/samples/: uploaddata.c wn_sample_upload.c netsetting.c deviceinfoasp.c wn_sample.c
    ../../../../APP_Framework/Applications/webnet/WebNet_XiUOS/src/: wn_request.c webnet.c wn_mimetype.c wn_session.c wn_utils.c wn_module.c
  group xip
    xip/: fsl_flexspi_nor_flash.c fsl_flexspi_nor_boot.c
